# Keil uVision project SCSI2SD_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5268AXI-LP047 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: SCSI2SD_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h SCSI_In_DBx_aliases.h SCSI_In_DBx.c SCSI_In_DBx.h SCSI_Out_DBx_aliases.h SCSI_Out_DBx.c SCSI_Out_DBx.h SD_MISO_aliases.h SD_MISO.c SD_MISO.h SD_MOSI_aliases.h SD_MOSI.c SD_MOSI.h SD_SCK_aliases.h SD_SCK.c SD_SCK.h SD_CS_aliases.h SD_CS.c SD_CS.h SD_DAT1_aliases.h SD_DAT1.c SD_DAT1.h SD_DAT2_aliases.h SD_DAT2.c SD_DAT2.h SD_WP_aliases.h SD_WP.c SD_WP.h SD_CD_aliases.h SD_CD.c SD_CD.h SCSI_ID_aliases.h PARITY_EN_aliases.h PARITY_EN.c PARITY_EN.h LED1_aliases.h LED1.c LED1.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h SCSI_In_aliases.h SCSI_Out_aliases.h SD_Init_Clk.c SD_Init_Clk.h SD_Data_Clk.c SD_Data_Clk.h SD_Clk_Ctl.c SD_Clk_Ctl.h SDCard.c SDCard.h SDCard_PM.c SDCard_INT.c SDCard_PVT.h
target Release (ARM-GNU)
  device: CY8C5268AXI-LP047 Cypress
  cpu: as above
  output: SCSI2SD_PSoC5lib (library)
